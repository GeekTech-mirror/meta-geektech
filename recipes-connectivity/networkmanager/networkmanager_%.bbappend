
FILESEXTRAPATHS:prepend := "${THISDIR}/${BP}:"

BBCLASSEXTEND = "native"