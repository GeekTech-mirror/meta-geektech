# add options to fix issues with creating monitoring interface
PACKAGECONFIG:append = " ipv6 libnl"