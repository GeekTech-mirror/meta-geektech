PACKAGECONFIG:append:rpi = " xz" 
