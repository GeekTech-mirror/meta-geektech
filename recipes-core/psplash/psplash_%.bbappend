FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SPLASH_IMAGES:rpi = "file://geektech_logo-img.h;outsuffix=raspberrypi"
